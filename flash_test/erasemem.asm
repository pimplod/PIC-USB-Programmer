#include <p18F14K50.inc>
EXTERN target_code_loc
CODE
erasemem
	MOVLW 00h
	MOVWF TBLPTRU
	MOVLW 00h
	MOVWF TBLPTRH
	MOVLW 80h
	MOVWF TBLPTRL
	
	BSF	EECON1, EEPGD
	BCF EECON1, CFGS
	BSF EECON1, WREN
	BSF EECON1, FREE
	BSF EECON1, GIE
	
	MOVLW 55h
	MOVWF EECON2
	
	MOVLW 0AAh
	MOVWF EECON2
	BSF	EECON1, WR
	NOP
	NOP
	BSF INTCON, GIE
	GLOBAL erasemem
	END